options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: oqpsk_sniffer
    output_language: python
    realtime_scheduling: '1'
    run_options: run
    title: IEEE 802.15.4 Sniffer
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: '{ i: 1000000 * (2400 + 5 * (i - 10)) for i in range(11, 27)}[channel]'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /tmp/sensor.pcap
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: channel
  id: parameter
  parameters:
    label: Channel
    short_id: c
    type: intx
    value: '15'
  states: {}
- name: foo_wireshark_connector_0
  id: foo_wireshark_connector
  parameters:
    debug: 'False'
    tech: '195'
  states: {}
- name: gain
  id: parameter
  parameters:
    label: Gain
    short_id: g
    type: eng_float
    value: '0.75'
  states: {}
- name: ieee802_15_4_oqpsk_phy_0
  id: ieee802_15_4_oqpsk_phy
  parameters: {}
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    center_freq0: freq
    clock_rate: '0.0'
    dev_addr: ''
    dev_args: '""'
    gain0: gain
    gain_type0: normalized
    samp_rate: '4000000'
    sync: sync
    type: fc32
  states: {}

connections:
- [foo_wireshark_connector_0, '0', blocks_file_sink_0, '0']
- [ieee802_15_4_oqpsk_phy_0, '0', blocks_null_sink_0, '0']
- [ieee802_15_4_oqpsk_phy_0, rxout, foo_wireshark_connector_0, in]
- [uhd_usrp_source_0, '0', ieee802_15_4_oqpsk_phy_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
